require recipes-images/images/core-image-graphical.inc