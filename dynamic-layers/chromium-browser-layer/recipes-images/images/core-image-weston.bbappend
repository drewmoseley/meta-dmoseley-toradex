require core-image-graphical-chromium.inc
IMAGE_INSTALL:append = " chromium-ozone-wayland "
