require core-image-graphical-chromium.inc
