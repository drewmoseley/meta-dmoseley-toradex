require core-image-graphical-cog.inc
