require recipes-images/images/core-image-headless.inc
IMAGE_INSTALL:append = " dmoseley-extra-files "
