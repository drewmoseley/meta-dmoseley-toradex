require core-image-headless.inc