require recipes-images/images/core-image-headless.inc