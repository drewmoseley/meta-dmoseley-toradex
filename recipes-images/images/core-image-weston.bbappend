require core-image-graphical.inc