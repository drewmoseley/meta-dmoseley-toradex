FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_torizon = " file://enable-nfs.cfg "
SRC_URI_append_torizon-upstream = " file://enable-nfs.cfg "
