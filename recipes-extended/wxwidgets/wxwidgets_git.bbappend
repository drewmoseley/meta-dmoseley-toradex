PACKAGECONFIG += "qt"
PACKAGECONFIG_remove = " gtk "
