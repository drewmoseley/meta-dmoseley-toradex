PACKAGECONFIG += "qt"
PACKAGECONFIG:remove = " gtk "
